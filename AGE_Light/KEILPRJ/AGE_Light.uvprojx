# Keil uVision project AGE_Light.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F3277G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER   __KEIL
  c include: ..\..\..\..\..\Device\MM32F327x\Include;..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\TCP;..\HARDWARE\BSP;..\..\LWIP\src;..\..\LWIP\src\arch;..\..\LWIP\src\include;..\..\LWIP\src\include\compat;..\..\LWIP\src\include\netif;..\..\LWIP\src\include\lwip;..\..\LWIP\src\include\lwip\apps;..\..\LWIP\src\include\lwip\priv;..\..\LWIP\src\include\lwip\prot;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\..\..\..\..\Device\MM32F327x\Source\KEIL_StartAsm;..\HARDWARE\SIM_EEPROM;..\HARDWARE\RTC;..\HARDWARE\TIM;..\HARDWARE\FSMC_SRAM;..\Use_Headfile;..\Boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group HARDWARE
    ../HARDWARE/BSP/: eth_bsp_config.c
    ../HARDWARE/TCP/: tcpecho.c
    ../HARDWARE/FSMC_SRAM/: fsmc_sram.c sram.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIM/: tim1_interrupt.c
    ../HARDWARE/SIM_EEPROM/: sim_eeprom.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group Use_Source
    ../Use_Source/: Abnormal.c AD8688.c AGE_CtrlDrive.c Calibration.c DataMath.c DataSave.c EndLimite_test.c ETHCommunication.c Flash_Data.c GY_CPLD.c Inter_init.c interrupt.c MB88346B.c Miscellaneous.c ProgrammCtrl.c Sample.c SampleDataDeal.c StepTypeCtrl.c
  group LWIP\arch
    ../../LWIP/src/arch/: ethernetif.c sys_arch.c
  group LWIP\core
    ../../LWIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group LWIP\core\ipv4
    ../../LWIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP\netif
    ../../LWIP/src/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group LWIP/api
    ../../LWIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group HAL_Lib
    ../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group Boot
    ../Boot/: boot_api.c iap.c drv_sys.c
